# Keil uVision project demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYS;..\FWLIB;..\FUNS;..\CORE;..\..\Demo;..\FWLIB\inc;..\HARDWARE;..\USB\usb\inc;..\USB\usb;..\HARDWARE\oled;..\SOFTWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c main.h
  group SYS
    ../SYS/: delay.c sys.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/: led.c KeyBoard.c bsp_usart.c WS2811.c time.c
    ../HARDWARE/oled/: oled.c
  group SOFTWARE
    ../SOFTWARE/: rng.c snake.c menu.c
  group USB_lib
    ../USB/usb/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_
    ../USB/usb/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c my_usb_init.c
